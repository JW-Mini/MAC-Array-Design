

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO systolic_array 
  PIN CLK 
    ANTENNAPARTIALMETALAREA 0.21735 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8694 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.0784 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.392 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal4 ; 
    ANTENNAMAXAREACAR 7.97317 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 35.5951 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.717073 LAYER via4 ;
  END CLK
  PIN RSTB 
    ANTENNAPARTIALMETALAREA 0.16135 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6454 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal3 ; 
    ANTENNAMAXAREACAR 12.6341 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 49.4585 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.478049 LAYER via3 ;
  END RSTB
  PIN IN1[7] 
    ANTENNAPARTIALMETALAREA 0.182 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7476 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal3 ; 
    ANTENNAMAXAREACAR 13.6415 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 54.4439 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.478049 LAYER via3 ;
  END IN1[7]
  PIN IN1[6] 
    ANTENNAPARTIALMETALAREA 0.2849 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1592 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal3 ; 
    ANTENNAMAXAREACAR 18.9683 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 75.7512 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.478049 LAYER via3 ;
  END IN1[6]
  PIN IN1[5] 
    ANTENNAPARTIALMETALAREA 0.19215 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7686 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.1764 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.784 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal4 ; 
    ANTENNAMAXAREACAR 15.178 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 64.4146 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.717073 LAYER via4 ;
  END IN1[5]
  PIN IN1[4] 
    ANTENNAPARTIALMETALAREA 0.1421 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.588 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal3 ; 
    ANTENNAMAXAREACAR 12.1732 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 48.5707 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.478049 LAYER via3 ;
  END IN1[4]
  PIN IN1[3] 
    ANTENNAPARTIALMETALAREA 0.0098 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0588 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal3 ; 
    ANTENNAMAXAREACAR 16.9878 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 65.7902 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.478049 LAYER via3 ;
  END IN1[3]
  PIN IN1[2] 
    ANTENNAPARTIALMETALAREA 0.2051 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.84 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal3 ; 
    ANTENNAMAXAREACAR 14.1195 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 56.3561 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.478049 LAYER via3 ;
  END IN1[2]
  PIN IN1[1] 
    ANTENNAPARTIALMETALAREA 0.1155 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4816 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal3 ; 
    ANTENNAMAXAREACAR 17.4317 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 69.0488 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.478049 LAYER via3 ;
  END IN1[1]
  PIN IN1[0] 
    ANTENNAPARTIALMETALAREA 0.1687 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6944 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal3 ; 
    ANTENNAMAXAREACAR 20.6756 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 82.5805 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.478049 LAYER via3 ;
  END IN1[0]
  PIN IN2[7] 
    ANTENNAPARTIALMETALAREA 0.2583 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0724 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal3 ; 
    ANTENNAMAXAREACAR 17.3634 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 70.2878 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.478049 LAYER via3 ;
  END IN2[7]
  PIN IN2[6] 
    ANTENNAPARTIALMETALAREA 0.09415 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3766 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.1764 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.784 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal4 ; 
    ANTENNAMAXAREACAR 21.8707 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 91.1854 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.717073 LAYER via4 ;
  END IN2[6]
  PIN IN2[5] 
    ANTENNAPARTIALMETALAREA 0.4046 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.638 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal3 ; 
    ANTENNAMAXAREACAR 23.8512 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 95.2829 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.478049 LAYER via3 ;
  END IN2[5]
  PIN IN2[4] 
    ANTENNAPARTIALMETALAREA 0.00665 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0266 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal3 ; 
    ANTENNAMAXAREACAR 16.8341 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 64.2195 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.478049 LAYER via3 ;
  END IN2[4]
  PIN IN2[3] 
    ANTENNAPARTIALMETALAREA 0.53165 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.1266 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal3 ; 
    ANTENNAMAXAREACAR 29.5707 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 117.205 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.478049 LAYER via3 ;
  END IN2[3]
  PIN IN2[2] 
    ANTENNAPARTIALMETALAREA 0.3549 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.4392 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal3 ; 
    ANTENNAMAXAREACAR 21.9049 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 87.4976 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.478049 LAYER via3 ;
  END IN2[2]
  PIN IN2[1] 
    ANTENNAPARTIALMETALAREA 0.17955 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7182 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal3 ; 
    ANTENNAMAXAREACAR 14.478 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 56.8341 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.478049 LAYER via3 ;
  END IN2[1]
  PIN IN2[0] 
    ANTENNAPARTIALMETALAREA 0.24255 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9898 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal3 ; 
    ANTENNAMAXAREACAR 14.9902 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 59.839 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.478049 LAYER via3 ;
  END IN2[0]
  PIN IN3[7] 
    ANTENNAPARTIALMETALAREA 0.1652 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal3 ; 
    ANTENNAMAXAREACAR 12.6512 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 51.439 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.478049 LAYER via3 ;
  END IN3[7]
  PIN IN3[6] 
    ANTENNAPARTIALMETALAREA 0.16765 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6902 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal3 ; 
    ANTENNAMAXAREACAR 17.1927 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 68.6488 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.478049 LAYER via3 ;
  END IN3[6]
  PIN IN3[5] 
    ANTENNAPARTIALMETALAREA 0.3647 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.498 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal3 ; 
    ANTENNAMAXAREACAR 20.9488 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 84.6293 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.478049 LAYER via3 ;
  END IN3[5]
  PIN IN3[4] 
    ANTENNAPARTIALMETALAREA 0.2478 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0304 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal3 ; 
    ANTENNAMAXAREACAR 17.278 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 69.9463 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.478049 LAYER via3 ;
  END IN3[4]
  PIN IN3[3] 
    ANTENNAPARTIALMETALAREA 0.2849 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1788 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal3 ; 
    ANTENNAMAXAREACAR 18.0122 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 72.8829 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.478049 LAYER via3 ;
  END IN3[3]
  PIN IN3[2] 
    ANTENNAPARTIALMETALAREA 0.315 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.2796 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal3 ; 
    ANTENNAMAXAREACAR 20.4366 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 81.6244 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.478049 LAYER via3 ;
  END IN3[2]
  PIN IN3[1] 
    ANTENNAPARTIALMETALAREA 0.13335 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5334 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.294 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.2544 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal4 ; 
    ANTENNAMAXAREACAR 29.5195 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 121.224 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.717073 LAYER via4 ;
  END IN3[1]
  PIN IN3[0] 
    ANTENNAPARTIALMETALAREA 0.30205 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.2082 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal3 ; 
    ANTENNAMAXAREACAR 21.239 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 83.878 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.478049 LAYER via3 ;
  END IN3[0]
  PIN W1[7] 
    ANTENNAPARTIALMETALAREA 0.0882 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4312 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal4 ; 
    ANTENNAMAXAREACAR 27.4707 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 113.585 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.717073 LAYER via4 ;
  END W1[7]
  PIN W1[6] 
    ANTENNAPARTIALMETALAREA 0.1862 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8232 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal4 ; 
    ANTENNAMAXAREACAR 22.161 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 92.3463 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.717073 LAYER via4 ;
  END W1[6]
  PIN W1[5] 
    ANTENNAPARTIALMETALAREA 0.049 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2744 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal4 ; 
    ANTENNAMAXAREACAR 14.6488 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 62.3317 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.717073 LAYER via4 ;
  END W1[5]
  PIN W1[4] 
    ANTENNAPARTIALMETALAREA 0.2254 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.98 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal4 ; 
    ANTENNAMAXAREACAR 20.9829 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 87.6341 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.717073 LAYER via4 ;
  END W1[4]
  PIN W1[3] 
    ANTENNAPARTIALMETALAREA 0.6958 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.8616 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal4 ; 
    ANTENNAMAXAREACAR 43.7927 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 178.873 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.717073 LAYER via4 ;
  END W1[3]
  PIN W1[2] 
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal4 ; 
    ANTENNAMAXAREACAR 13.2317 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 52.8049 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.717073 LAYER via4 ;
  END W1[2]
  PIN W1[1] 
    ANTENNAPARTIALMETALAREA 0.2548 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0192 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal4 ; 
    ANTENNAMAXAREACAR 26.5488 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 106.073 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.717073 LAYER via4 ;
  END W1[1]
  PIN W1[0] 
    ANTENNAPARTIALMETALAREA 0.245 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0584 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal4 ; 
    ANTENNAMAXAREACAR 25.2854 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 104.844 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.717073 LAYER via4 ;
  END W1[0]
  PIN W2[7] 
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal4 ; 
    ANTENNAMAXAREACAR 21.1878 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 88.4537 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.717073 LAYER via4 ;
  END W2[7]
  PIN W2[6] 
    ANTENNAPARTIALMETALAREA 0.4802 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.9992 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal4 ; 
    ANTENNAMAXAREACAR 34.1293 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 140.22 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.717073 LAYER via4 ;
  END W2[6]
  PIN W2[5] 
    ANTENNAPARTIALMETALAREA 0.4312 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.7248 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 0.098 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4704 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal5 ; 
    ANTENNAMAXAREACAR 18.0463 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 79.7122 LAYER metal5 ;
    ANTENNAMAXCUTCAR 1.67317 LAYER via5 ;
  END W2[5]
  PIN W2[4] 
    ANTENNAPARTIALMETALAREA 0.196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.784 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal4 ; 
    ANTENNAMAXAREACAR 37.3049 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 149.098 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.717073 LAYER via4 ;
  END W2[4]
  PIN W2[3] 
    ANTENNAPARTIALMETALAREA 0.0294 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.196 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal4 ; 
    ANTENNAMAXAREACAR 18.3195 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 76.9805 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.717073 LAYER via4 ;
  END W2[3]
  PIN W2[2] 
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal4 ; 
    ANTENNAMAXAREACAR 20.9488 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 87.4976 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.717073 LAYER via4 ;
  END W2[2]
  PIN W2[1] 
    ANTENNAPARTIALMETALAREA 0.2156 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8624 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal4 ; 
    ANTENNAMAXAREACAR 21.3927 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 85.4488 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.717073 LAYER via4 ;
  END W2[1]
  PIN W2[0] 
    ANTENNAPARTIALMETALAREA 0.0686 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3528 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal4 ; 
    ANTENNAMAXAREACAR 25.8659 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 107.166 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.717073 LAYER via4 ;
  END W2[0]
  PIN W3[7] 
    ANTENNAPARTIALMETALAREA 0.49 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0384 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal4 ; 
    ANTENNAMAXAREACAR 30.8512 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 127.107 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.717073 LAYER via4 ;
  END W3[7]
  PIN W3[6] 
    ANTENNAPARTIALMETALAREA 0.2352 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9408 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 0.2548 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0976 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal5 ; 
    ANTENNAMAXAREACAR 37.8854 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 159.068 LAYER metal5 ;
    ANTENNAMAXCUTCAR 1.67317 LAYER via5 ;
  END W3[6]
  PIN W3[5] 
    ANTENNAPARTIALMETALAREA 0.2646 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1368 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal4 ; 
    ANTENNAMAXAREACAR 29.8951 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 123.283 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.717073 LAYER via4 ;
  END W3[5]
  PIN W3[4] 
    ANTENNAPARTIALMETALAREA 0.049 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2744 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal4 ; 
    ANTENNAMAXAREACAR 22.6561 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 94.3268 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.717073 LAYER via4 ;
  END W3[4]
  PIN W3[3] 
    ANTENNAPARTIALMETALAREA 0.4704 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.8816 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal4 ; 
    ANTENNAMAXAREACAR 31.4659 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 125.741 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.717073 LAYER via4 ;
  END W3[3]
  PIN W3[2] 
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0784 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal4 ; 
    ANTENNAMAXAREACAR 19.6171 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 78.3463 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.717073 LAYER via4 ;
  END W3[2]
  PIN W3[1] 
    ANTENNAPARTIALMETALAREA 0.0392 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal4 ; 
    ANTENNAMAXAREACAR 24.022 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 95.9659 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.717073 LAYER via4 ;
  END W3[1]
  PIN W3[0] 
    ANTENNAPARTIALMETALAREA 0.392 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.568 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0205 LAYER metal4 ; 
    ANTENNAMAXAREACAR 33.7195 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 134.756 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.717073 LAYER via4 ;
  END W3[0]
  PIN OUT1[19] 
    ANTENNAPARTIALMETALAREA 0.1442 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5356 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNADIFFAREA 0.109725 LAYER metal2 ; 
    ANTENNAPARTIALMETALAREA 0.399 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.6156 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.3983 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.6324 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.11325 LAYER metal3 ; 
    ANTENNAMAXAREACAR 5.72623 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 22.7504 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT1[19]
  PIN OUT1[18] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.3157 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.2824 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2954 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.2012 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.03475 LAYER metal3 ; 
    ANTENNAMAXAREACAR 10.0719 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 41.3525 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT1[18]
  PIN OUT1[17] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNADIFFAREA 0.109725 LAYER metal2 ; 
    ANTENNAPARTIALMETALAREA 0.7742 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.1164 LAYER metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.105 LAYER metal2 ; 
    ANTENNAMAXAREACAR 8.96 LAYER metal2 ;
    ANTENNAMAXSIDEAREACAR 35.6229 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.0933333 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2758 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1228 LAYER metal3 ;
    ANTENNAGATEAREA 0.13975 LAYER metal3 ; 
    ANTENNAMAXAREACAR 10.9335 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 43.6572 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT1[17]
  PIN OUT1[16] 
    ANTENNAPARTIALMETALAREA 0.01715 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0637 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.9821 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.948 LAYER metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.105 LAYER metal2 ; 
    ANTENNAMAXAREACAR 10.94 LAYER metal2 ;
    ANTENNAMAXSIDEAREACAR 43.5429 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.14 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2856 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1816 LAYER metal3 ;
    ANTENNAGATEAREA 0.13975 LAYER metal3 ; 
    ANTENNAMAXAREACAR 12.9836 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 51.998 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT1[16]
  PIN OUT1[15] 
    ANTENNAPARTIALMETALAREA 0.01715 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0637 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.2355 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.9812 LAYER metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.105 LAYER metal2 ; 
    ANTENNAMAXAREACAR 13.3533 LAYER metal2 ;
    ANTENNAMAXSIDEAREACAR 53.3829 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.0933333 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.329 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3356 LAYER metal3 ;
    ANTENNAGATEAREA 0.13975 LAYER metal3 ; 
    ANTENNAMAXAREACAR 15.7075 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 62.9399 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT1[15]
  PIN OUT1[14] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1176 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.49 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.518 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.1308 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 33.7322 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 135.948 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.423022 LAYER via3 ;
  END OUT1[14]
  PIN OUT1[13] 
    ANTENNAPARTIALMETALAREA 0.0413 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1534 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.2548 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0388 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.8442 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.416 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 33.5846 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 135.185 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.423022 LAYER via3 ;
  END OUT1[13]
  PIN OUT1[12] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.4851 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.9796 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.7938 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.234 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 13.6027 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 54.7359 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT1[12]
  PIN OUT1[11] 
    ANTENNAPARTIALMETALAREA 0.0182 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0676 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.4378 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.7904 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.5481 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.2316 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 9.36241 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 37.602 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT1[11]
  PIN OUT1[10] 
    ANTENNAPARTIALMETALAREA 0.0049 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0182 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.2303 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9408 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.3437 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3944 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 1.7444 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 7.056 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 26.0306 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 104.965 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.466193 LAYER via4 ;
  END OUT1[10]
  PIN OUT1[9] 
    ANTENNAPARTIALMETALAREA 0.01715 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0637 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.3706 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.502 LAYER metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.03475 LAYER metal2 ; 
    ANTENNAMAXAREACAR 40.4489 LAYER metal2 ;
    ANTENNAMAXSIDEAREACAR 162.296 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2758 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1228 LAYER metal3 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 42.8789 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 172.189 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT1[9]
  PIN OUT1[8] 
    ANTENNAPARTIALMETALAREA 0.1043 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3874 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.4651 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.88 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2758 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1228 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 9.58551 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 38.3217 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT1[8]
  PIN OUT1[7] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.7364 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9652 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.4053 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.6604 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 9.68648 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 38.8983 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT1[7]
  PIN OUT1[6] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.3647 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.498 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.1085 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4536 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.4312 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.8032 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 0.1764 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.784 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal5 ; 
    ANTENNAMAXAREACAR 37.1122 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 149.983 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.638881 LAYER via5 ;
  END OUT1[6]
  PIN OUT1[5] 
    ANTENNAPARTIALMETALAREA 0.0147 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0546 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.147 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6076 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.0357 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1624 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 3.5476 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.3472 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 41.3485 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 167.84 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.564029 LAYER via4 ;
  END OUT1[5]
  PIN OUT1[4] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNADIFFAREA 0.109725 LAYER metal2 ; 
    ANTENNAPARTIALMETALAREA 1.55365 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 6.2342 LAYER metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.07875 LAYER metal2 ; 
    ANTENNAMAXAREACAR 22.8933 LAYER metal2 ;
    ANTENNAMAXSIDEAREACAR 91.3803 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.124444 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2723 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1088 LAYER metal3 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 25.2925 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 101.149 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT1[4]
  PIN OUT1[3] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.2026 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.83 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.329 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3356 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 7.35201 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 29.3877 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT1[3]
  PIN OUT1[2] 
    ANTENNAPARTIALMETALAREA 0.0511 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1898 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNADIFFAREA 0.109725 LAYER metal2 ; 
    ANTENNAPARTIALMETALAREA 1.1816 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.746 LAYER metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.07875 LAYER metal2 ; 
    ANTENNAMAXAREACAR 18.1689 LAYER metal2 ;
    ANTENNAMAXSIDEAREACAR 72.4825 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.124444 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2954 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.2012 LAYER metal3 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 20.7715 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 83.0658 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT1[2]
  PIN OUT1[1] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.9555 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.8416 LAYER metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.03475 LAYER metal2 ; 
    ANTENNAMAXAREACAR 28.5036 LAYER metal2 ;
    ANTENNAMAXSIDEAREACAR 114.515 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.423022 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.4116 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.6856 LAYER metal3 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 32.13 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 129.366 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.423022 LAYER via3 ;
  END OUT1[1]
  PIN OUT1[0] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.0833 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3528 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.4585 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.8732 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1395 LAYER metal3 ; 
    ANTENNAMAXAREACAR 5.80774 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 23.5502 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT1[0]
  PIN OUT2[19] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.53725 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.1686 LAYER metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.11325 LAYER metal2 ; 
    ANTENNAMAXAREACAR 6.70348 LAYER metal2 ;
    ANTENNAMAXSIDEAREACAR 26.2367 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.184274 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2758 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1228 LAYER metal3 ;
    ANTENNAGATEAREA 0.11325 LAYER metal3 ; 
    ANTENNAMAXAREACAR 9.1388 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 36.151 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.184274 LAYER via3 ;
  END OUT2[19]
  PIN OUT2[18] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNADIFFAREA 0.109725 LAYER metal2 ; 
    ANTENNAPARTIALMETALAREA 0.2177 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8904 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2856 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.162 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.03475 LAYER metal3 ; 
    ANTENNAMAXAREACAR 10.354 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 42.4806 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT2[18]
  PIN OUT2[17] 
    ANTENNAPARTIALMETALAREA 0.1575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.6678 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.6908 LAYER metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.105 LAYER metal2 ; 
    ANTENNAMAXAREACAR 7.94667 LAYER metal2 ;
    ANTENNAMAXSIDEAREACAR 31.5695 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.0933333 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2758 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1228 LAYER metal3 ;
    ANTENNAGATEAREA 0.13975 LAYER metal3 ; 
    ANTENNAMAXAREACAR 9.92019 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 39.6039 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT2[17]
  PIN OUT2[16] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.889 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5756 LAYER metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.105 LAYER metal2 ; 
    ANTENNAMAXAREACAR 10.0533 LAYER metal2 ;
    ANTENNAMAXSIDEAREACAR 39.9962 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.0933333 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2758 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1228 LAYER metal3 ;
    ANTENNAGATEAREA 0.13975 LAYER metal3 ; 
    ANTENNAMAXAREACAR 12.0269 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 48.0305 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT2[16]
  PIN OUT2[15] 
    ANTENNAPARTIALMETALAREA 0.01715 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0637 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1176 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.49 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.0805 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3416 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 1.4896 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.0368 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.13975 LAYER metal4 ; 
    ANTENNAMAXAREACAR 23.0311 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 93.3262 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.317077 LAYER via4 ;
  END OUT2[15]
  PIN OUT2[14] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1127 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4704 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.6314 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5452 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 5.4292 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 21.8736 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 69.5899 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 279.893 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.325186 LAYER via4 ;
  END OUT2[14]
  PIN OUT2[13] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1225 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5096 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.0224 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1092 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 9.2512 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 37.3184 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal5 ; 
    ANTENNAMAXAREACAR 104.649 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 422.126 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.400038 LAYER via5 ;
  END OUT2[13]
  PIN OUT2[12] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1029 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4312 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.0294 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1372 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 3.0772 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 12.3872 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal5 ; 
    ANTENNAMAXAREACAR 90.2572 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 362.563 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.497873 LAYER via5 ;
  END OUT2[12]
  PIN OUT2[11] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.2422 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9884 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.8631 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.4916 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 1.5876 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.4288 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 5.1352 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 20.6976 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal5 ; 
    ANTENNAMAXAREACAR 57.5302 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 233.039 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.497873 LAYER via5 ;
  END OUT2[11]
  PIN OUT2[10] 
    ANTENNAPARTIALMETALAREA 0.091 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.338 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.4119 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.6672 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.9751 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.9396 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 1.8816 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 7.6048 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 34.1626 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 137.839 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.325186 LAYER via4 ;
  END OUT2[10]
  PIN OUT2[9] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.0294 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1372 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.021 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1036 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 3.8612 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 15.5232 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal5 ; 
    ANTENNAMAXAREACAR 97.7808 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 395.515 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.736716 LAYER via5 ;
  END OUT2[9]
  PIN OUT2[8] 
    ANTENNAPARTIALMETALAREA 0.0812 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3016 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.0784 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3528 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.0119 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0672 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 6.0172 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 24.2256 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 69.1487 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 278.474 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.466193 LAYER via4 ;
  END OUT2[8]
  PIN OUT2[7] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.15295 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6314 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.5495 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.2176 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 5.9976 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 24.1472 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 1.9012 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 7.6832 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal5 ; 
    ANTENNAMAXAREACAR 57.9617 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 234.984 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.736716 LAYER via5 ;
  END OUT2[7]
  PIN OUT2[6] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.5026 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.03 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.2898 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1984 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 3.9984 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.072 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 2.5284 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 10.192 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal5 ; 
    ANTENNAMAXAREACAR 43.2352 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 175.341 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.779888 LAYER via5 ;
  END OUT2[6]
  PIN OUT2[5] 
    ANTENNAPARTIALMETALAREA 0.1575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.049 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2352 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.0105 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0616 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 6.6836 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 26.8128 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 74.6823 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 299.745 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.466193 LAYER via4 ;
  END OUT2[5]
  PIN OUT2[4] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 2.2771 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.1476 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.231 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9436 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 2.8224 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.368 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 41.4407 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 167.3 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.466193 LAYER via4 ;
  END OUT2[4]
  PIN OUT2[3] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.1319 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.5472 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 1.3083 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.2724 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 3.1752 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.7792 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 42.016 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 168.658 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.227351 LAYER via4 ;
  END OUT2[3]
  PIN OUT2[2] 
    ANTENNAPARTIALMETALAREA 0.0546 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2028 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.0098 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0588 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.8862 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5644 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 2.7244 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.0544 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 39.5527 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 159.745 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.325186 LAYER via4 ;
  END OUT2[2]
  PIN OUT2[1] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.4928 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.9908 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.2625 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0892 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 4.704 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.8944 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 49.3736 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 198.338 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.325186 LAYER via4 ;
  END OUT2[1]
  PIN OUT2[0] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.245 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0192 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.21 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8988 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 5.5664 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 22.344 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1395 LAYER metal4 ; 
    ANTENNAMAXAREACAR 51.9583 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 208.714 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.31714 LAYER via4 ;
  END OUT2[0]
  PIN OUT3[19] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.53585 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.163 LAYER metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.03475 LAYER metal2 ; 
    ANTENNAMAXAREACAR 16.4273 LAYER metal2 ;
    ANTENNAMAXSIDEAREACAR 66.2101 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.423022 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.4053 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.6604 LAYER metal3 ;
    ANTENNAGATEAREA 0.11325 LAYER metal3 ; 
    ANTENNAMAXAREACAR 20.0061 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 80.8714 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.423022 LAYER via3 ;
  END OUT3[19]
  PIN OUT3[18] 
    ANTENNAPARTIALMETALAREA 0.0049 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0182 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNADIFFAREA 0.109725 LAYER metal2 ; 
    ANTENNAPARTIALMETALAREA 0.224 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9156 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2758 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1228 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.03475 LAYER metal3 ; 
    ANTENNAMAXAREACAR 9.2259 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 37.9683 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT3[18]
  PIN OUT3[17] 
    ANTENNAPARTIALMETALAREA 0.0049 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0182 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.0441 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.196 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.5348 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.198 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.13975 LAYER metal3 ; 
    ANTENNAMAXAREACAR 5.68007 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 23.6418 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT3[17]
  PIN OUT3[16] 
    ANTENNAPARTIALMETALAREA 0.0049 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0182 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNADIFFAREA 0.109725 LAYER metal2 ; 
    ANTENNAPARTIALMETALAREA 0.987 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.9676 LAYER metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.105 LAYER metal2 ; 
    ANTENNAMAXAREACAR 11.0517 LAYER metal2 ;
    ANTENNAMAXSIDEAREACAR 43.9524 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.0933333 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2758 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1228 LAYER metal3 ;
    ANTENNAGATEAREA 0.13975 LAYER metal3 ; 
    ANTENNAMAXAREACAR 13.0252 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 51.9867 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT3[16]
  PIN OUT3[15] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1078 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4508 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.0266 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.126 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 5.096 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 20.5408 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.13975 LAYER metal4 ; 
    ANTENNAMAXAREACAR 56.9615 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 230.597 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.423022 LAYER via4 ;
  END OUT3[15]
  PIN OUT3[14] 
    ANTENNAPARTIALMETALAREA 0.0546 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2028 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1274 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5488 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.0147 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0784 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 6.37 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 25.5584 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 82.1158 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 329.307 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.325186 LAYER via4 ;
  END OUT3[14]
  PIN OUT3[13] 
    ANTENNAPARTIALMETALAREA 0.0049 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0182 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1421 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.588 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.2807 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1424 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 5.4488 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 21.952 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 59.9847 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 241.569 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.270523 LAYER via4 ;
  END OUT3[13]
  PIN OUT3[12] 
    ANTENNAPARTIALMETALAREA 0.0049 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0182 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.0098 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0588 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.8925 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5896 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 7.2716 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 29.1648 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 1.5092 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 6.1152 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal5 ; 
    ANTENNAMAXAREACAR 34.7366 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 141.347 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.638881 LAYER via5 ;
  END OUT3[12]
  PIN OUT3[11] 
    ANTENNAPARTIALMETALAREA 0.0049 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0182 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.5341 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.156 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.6447 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.618 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 3.92 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.7584 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 4.0964 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 16.6208 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal5 ; 
    ANTENNAMAXAREACAR 54.3289 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 220.231 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.497873 LAYER via5 ;
  END OUT3[11]
  PIN OUT3[10] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.0784 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3332 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 1.344 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.3956 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 4.0376 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.3072 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 2.7636 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 11.1328 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal5 ; 
    ANTENNAMAXAREACAR 79.6298 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 321.656 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.595709 LAYER via5 ;
  END OUT3[10]
  PIN OUT3[9] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.3528 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.4308 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 1.0038 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.0348 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 6.37 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 25.6368 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 91.0931 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 368.511 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.705036 LAYER via4 ;
  END OUT3[9]
  PIN OUT3[8] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.6202 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.52 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.0826 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3696 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.98 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.9984 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 0.882 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 3.6064 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal5 ; 
    ANTENNAMAXAREACAR 114.294 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 460.875 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.736716 LAYER via5 ;
  END OUT3[8]
  PIN OUT3[7] 
    ANTENNAPARTIALMETALAREA 0.0413 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1534 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 2.0209 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 8.1228 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.1659 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6832 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 3.9984 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.072 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 53.3033 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 214.056 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.325186 LAYER via4 ;
  END OUT3[7]
  PIN OUT3[6] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.0245 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1176 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.0812 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3444 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 6.0564 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 24.4608 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal5 ; 
    ANTENNAMAXAREACAR 101.314 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 409.084 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.595709 LAYER via5 ;
  END OUT3[6]
  PIN OUT3[5] 
    ANTENNAPARTIALMETALAREA 0.01715 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0637 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1078 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4508 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.0889 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3752 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 3.3516 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.4848 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 5.7232 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 23.0496 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal5 ; 
    ANTENNAMAXAREACAR 68.3476 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 276.133 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.497873 LAYER via5 ;
  END OUT3[5]
  PIN OUT3[4] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1323 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5488 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.3962 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.6044 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 5.488 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 22.1088 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 2.45 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 9.8784 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal5 ; 
    ANTENNAMAXAREACAR 51.5635 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 207.788 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.497873 LAYER via5 ;
  END OUT3[4]
  PIN OUT3[3] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1127 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.49 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.098 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 5.39 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 21.6384 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 9.4668 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 37.9456 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal5 ; 
    ANTENNAMAXAREACAR 124.022 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 497.451 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.497873 LAYER via5 ;
  END OUT3[3]
  PIN OUT3[2] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.211 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.8636 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.7658 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.1024 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.2352 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0192 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 1.078 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.3904 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal5 ; 
    ANTENNAMAXAREACAR 49.9292 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 201.423 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.497873 LAYER via5 ;
  END OUT3[2]
  PIN OUT3[1] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.0147 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0784 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 1.9677 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.9296 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 4.1552 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.6992 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 60.7643 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 243.9 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.325186 LAYER via4 ;
  END OUT3[1]
  PIN OUT3[0] 
    ANTENNAPARTIALMETALAREA 0.0679 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2522 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.252 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0276 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 1.5743 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.3952 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.294 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.2544 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 3.7828 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 15.3664 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1395 LAYER metal5 ; 
    ANTENNAMAXAREACAR 32.7988 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 134.225 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.457642 LAYER via5 ;
  END OUT3[0]
  PIN OUT4[19] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.5383 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.1728 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.3822 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5484 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.11325 LAYER metal3 ; 
    ANTENNAMAXAREACAR 7.75095 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 30.6762 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT4[19]
  PIN OUT4[18] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNADIFFAREA 0.109725 LAYER metal2 ; 
    ANTENNAPARTIALMETALAREA 0.2107 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8624 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2758 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1228 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.03475 LAYER metal3 ; 
    ANTENNAMAXAREACAR 9.2259 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 37.9683 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT4[18]
  PIN OUT4[17] 
    ANTENNAPARTIALMETALAREA 0.1043 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3874 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNADIFFAREA 0.109725 LAYER metal2 ; 
    ANTENNAPARTIALMETALAREA 0.4837 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.974 LAYER metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.105 LAYER metal2 ; 
    ANTENNAMAXAREACAR 6.19333 LAYER metal2 ;
    ANTENNAMAXSIDEAREACAR 24.7429 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.0933333 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2856 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.162 LAYER metal3 ;
    ANTENNAGATEAREA 0.13975 LAYER metal3 ; 
    ANTENNAMAXAREACAR 8.23698 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 33.0577 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT4[17]
  PIN OUT4[16] 
    ANTENNAPARTIALMETALAREA 0.0413 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1534 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.098 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.5509 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.2428 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.13975 LAYER metal3 ; 
    ANTENNAMAXAREACAR 10.1419 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 40.5847 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.211132 LAYER via3 ;
  END OUT4[16]
  PIN OUT4[15] 
    ANTENNAPARTIALMETALAREA 0.0182 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0676 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.9121 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.668 LAYER metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.105 LAYER metal2 ; 
    ANTENNAMAXAREACAR 10.3383 LAYER metal2 ;
    ANTENNAMAXSIDEAREACAR 41.099 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.0933333 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2758 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1228 LAYER metal3 ;
    ANTENNAGATEAREA 0.13975 LAYER metal3 ; 
    ANTENNAMAXAREACAR 12.3119 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 49.1334 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT4[15]
  PIN OUT4[14] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.2058 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8428 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.525 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.1392 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 19.1694 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 77.5238 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.423022 LAYER via3 ;
  END OUT4[14]
  PIN OUT4[13] 
    ANTENNAPARTIALMETALAREA 0.0147 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0546 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.2156 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.882 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 1.2194 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.9364 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 21.4636 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 86.1795 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT4[13]
  PIN OUT4[12] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNADIFFAREA 0.109725 LAYER metal2 ; 
    ANTENNAPARTIALMETALAREA 1.1207 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.522 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.4648 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.8984 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 9.15127 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 37.4512 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.423022 LAYER via3 ;
  END OUT4[12]
  PIN OUT4[11] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.3209 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.3228 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.5313 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.1448 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 7.96995 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 32.4509 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT4[11]
  PIN OUT4[10] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1568 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6468 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.4368 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.7668 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 2.6068 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.584 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 34.4696 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 140.324 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.564029 LAYER via4 ;
  END OUT4[10]
  PIN OUT4[9] 
    ANTENNAPARTIALMETALAREA 0.1043 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3874 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNADIFFAREA 0.109725 LAYER metal2 ; 
    ANTENNAPARTIALMETALAREA 1.1452 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.6004 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.6216 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.506 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 14.3744 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 57.4774 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT4[9]
  PIN OUT4[8] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.2922 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.1884 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.5117 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.086 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 9.70837 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 38.9858 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT4[8]
  PIN OUT4[7] 
    ANTENNAPARTIALMETALAREA 0.0049 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0182 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.2061 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.844 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.3556 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.442 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.03475 LAYER metal3 ; 
    ANTENNAMAXAREACAR 11.8043 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 48.282 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.423022 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 0.8232 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3712 LAYER metal4 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 19.0572 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 77.9842 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.423022 LAYER via4 ;
  END OUT4[7]
  PIN OUT4[6] 
    ANTENNAPARTIALMETALAREA 0.0679 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2522 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.3342 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.3564 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.4053 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.6604 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 9.52648 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 38.2583 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT4[6]
  PIN OUT4[5] 
    ANTENNAPARTIALMETALAREA 0.0049 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0182 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1029 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4312 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.2275 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9296 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 1.3916 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.6448 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 31.9711 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 129.421 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.466193 LAYER via4 ;
  END OUT4[5]
  PIN OUT4[4] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.0833 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3528 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.4228 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.7108 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 2.6264 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.584 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 32.7255 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 131.745 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.466193 LAYER via4 ;
  END OUT4[4]
  PIN OUT4[3] 
    ANTENNAPARTIALMETALAREA 0.0644 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2392 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.5166 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.086 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.0931 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4116 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 0.784 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2144 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 17.3833 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 70.2036 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.325186 LAYER via4 ;
  END OUT4[3]
  PIN OUT4[2] 
    ANTENNAPARTIALMETALAREA 0.5229 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 1.9422 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.4042 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.6364 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.3157 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.2824 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 7.9415 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 31.7457 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT4[2]
  PIN OUT4[1] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.0343 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.4452 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.82 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 8.00277 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 32.0872 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.184179 LAYER via3 ;
  END OUT4[1]
  PIN OUT4[0] 
    ANTENNAPARTIALMETALAREA 0.0182 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0676 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1764 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7252 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.5082 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.072 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1395 LAYER metal3 ; 
    ANTENNAMAXAREACAR 6.16401 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 24.9752 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT4[0]
  PIN OUT5[19] 
    ANTENNAPARTIALMETALAREA 0.0812 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3016 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.294 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1956 LAYER metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.03475 LAYER metal2 ; 
    ANTENNAMAXAREACAR 9.46763 LAYER metal2 ;
    ANTENNAMAXSIDEAREACAR 38.3712 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2954 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.2012 LAYER metal3 ;
    ANTENNAGATEAREA 0.11325 LAYER metal3 ; 
    ANTENNAMAXAREACAR 12.076 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 48.9778 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT5[19]
  PIN OUT5[18] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.4949 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.9992 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2954 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.2012 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.03475 LAYER metal3 ; 
    ANTENNAMAXAREACAR 10.0719 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 41.3525 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT5[18]
  PIN OUT5[17] 
    ANTENNAPARTIALMETALAREA 0.1309 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4862 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.6048 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.4388 LAYER metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.03475 LAYER metal2 ; 
    ANTENNAMAXAREACAR 18.4115 LAYER metal2 ;
    ANTENNAMAXSIDEAREACAR 74.1468 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2625 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0696 LAYER metal3 ;
    ANTENNAGATEAREA 0.13975 LAYER metal3 ; 
    ANTENNAMAXAREACAR 20.2899 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 81.8004 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT5[17]
  PIN OUT5[16] 
    ANTENNAPARTIALMETALAREA 0.0182 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0676 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.3626 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.47 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.4984 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0328 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.13975 LAYER metal3 ; 
    ANTENNAMAXAREACAR 9.35304 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 37.4755 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT5[16]
  PIN OUT5[15] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.9303 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.7408 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.6181 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5116 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.13975 LAYER metal3 ; 
    ANTENNAMAXAREACAR 7.83783 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 31.3683 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.211132 LAYER via3 ;
  END OUT5[15]
  PIN OUT5[14] 
    ANTENNAPARTIALMETALAREA 0.0413 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1534 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.3724 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5288 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.9247 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.7184 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 2.45 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.9568 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 39.953 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 161.27 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.227351 LAYER via4 ;
  END OUT5[14]
  PIN OUT5[13] 
    ANTENNAPARTIALMETALAREA 0.0147 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0546 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.9646 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.878 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.9912 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.0236 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 0.9212 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.7632 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 16.5846 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 67.1816 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.325186 LAYER via4 ;
  END OUT5[13]
  PIN OUT5[12] 
    ANTENNAPARTIALMETALAREA 0.0378 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1404 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.2558 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.0428 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.0371 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.168 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 2.8812 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.6816 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 54.6944 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 221.788 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.564029 LAYER via4 ;
  END OUT5[12]
  PIN OUT5[11] 
    ANTENNAPARTIALMETALAREA 0.0182 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0676 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.0098 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0588 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.6748 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.7188 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 3.9788 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.072 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.13975 LAYER metal4 ; 
    ANTENNAMAXAREACAR 38.0621 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 152.897 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.317077 LAYER via4 ;
  END OUT5[11]
  PIN OUT5[10] 
    ANTENNAPARTIALMETALAREA 0.0413 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1534 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.049 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2156 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.0217 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1064 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 2.2148 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 8.9376 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal5 ; 
    ANTENNAMAXAREACAR 69.2043 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 278.696 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.497873 LAYER via5 ;
  END OUT5[10]
  PIN OUT5[9] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1274 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5292 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.4536 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.834 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 3.724 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.9744 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 43.2934 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 174.189 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.325186 LAYER via4 ;
  END OUT5[9]
  PIN OUT5[8] 
    ANTENNAPARTIALMETALAREA 0.3136 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1648 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.098 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 1.2754 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.1408 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 2.4108 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.7216 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 44.5222 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 179.277 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.325186 LAYER via4 ;
  END OUT5[8]
  PIN OUT5[7] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1799 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7392 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 1.8606 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.4816 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 2.2932 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.2512 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 28.3077 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 114.074 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.325186 LAYER via4 ;
  END OUT5[7]
  PIN OUT5[6] 
    ANTENNAPARTIALMETALAREA 0.0546 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2028 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.0294 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1372 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.021 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1036 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 2.1756 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 8.7808 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal5 ; 
    ANTENNAMAXAREACAR 88.6603 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 356.251 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.497873 LAYER via5 ;
  END OUT5[6]
  PIN OUT5[5] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.2068 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.8468 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.0245 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1176 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 4.7824 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 19.2864 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 51.3616 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 207.893 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.423022 LAYER via4 ;
  END OUT5[5]
  PIN OUT5[4] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.098 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.084 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3556 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.0392 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2352 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 2.45 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 9.8784 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal5 ; 
    ANTENNAMAXAREACAR 90.9334 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 366.131 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.497873 LAYER via5 ;
  END OUT5[4]
  PIN OUT5[3] 
    ANTENNAPARTIALMETALAREA 0.0049 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0182 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.63 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5396 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.4102 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.6604 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 4.6648 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.816 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 52.0929 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 209.733 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.325186 LAYER via4 ;
  END OUT5[3]
  PIN OUT5[2] 
    ANTENNAPARTIALMETALAREA 0.0182 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0676 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1274 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5292 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.0588 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2548 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 1.862 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 7.5264 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.13975 LAYER metal4 ; 
    ANTENNAMAXAREACAR 23.6296 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 95.0264 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.317077 LAYER via4 ;
  END OUT5[2]
  PIN OUT5[1] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.3486 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.414 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.3262 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3244 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 4.9196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 19.7568 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.13975 LAYER metal4 ; 
    ANTENNAMAXAREACAR 42.1262 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 168.592 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.317077 LAYER via4 ;
  END OUT5[1]
  PIN OUT5[0] 
    ANTENNAPARTIALMETALAREA 0.0413 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1534 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.0882 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3724 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.0133 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0728 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.0196 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 2.45 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 9.8784 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1395 LAYER metal5 ; 
    ANTENNAMAXAREACAR 61.5483 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 247.636 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.457642 LAYER via5 ;
  END OUT5[0]
  PIN OUT6[19] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.5103 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0608 LAYER metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0785 LAYER metal2 ; 
    ANTENNAMAXAREACAR 8.46019 LAYER metal2 ;
    ANTENNAMAXSIDEAREACAR 33.3401 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.124841 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.3689 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.4952 LAYER metal3 ;
    ANTENNAGATEAREA 0.11325 LAYER metal3 ; 
    ANTENNAMAXAREACAR 11.7176 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 46.5428 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT6[19]
  PIN OUT6[18] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.224 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9156 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2758 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1228 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.03475 LAYER metal3 ; 
    ANTENNAMAXAREACAR 9.2259 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 37.9683 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT6[18]
  PIN OUT6[17] 
    ANTENNAPARTIALMETALAREA 0.0546 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2028 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.0098 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0588 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.3654 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5008 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.13975 LAYER metal3 ; 
    ANTENNAMAXAREACAR 10.8347 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 43.402 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT6[17]
  PIN OUT6[16] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.6874 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.7888 LAYER metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.105 LAYER metal2 ; 
    ANTENNAMAXAREACAR 8.13333 LAYER metal2 ;
    ANTENNAMAXSIDEAREACAR 32.5029 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.0933333 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.3619 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.4868 LAYER metal3 ;
    ANTENNAGATEAREA 0.13975 LAYER metal3 ; 
    ANTENNAMAXAREACAR 10.723 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 43.1419 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT6[16]
  PIN OUT6[15] 
    ANTENNAPARTIALMETALAREA 0.0777 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2886 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.8792 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5364 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 1.9467 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.826 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.105 LAYER metal3 ; 
    ANTENNAMAXAREACAR 20.9667 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 84.0229 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.186667 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 4.5864 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.424 LAYER metal4 ;
    ANTENNAGATEAREA 0.105 LAYER metal4 ; 
    ANTENNAMAXAREACAR 64.6467 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 259.49 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNAMAXCUTCAR 0.373333 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 3.7044 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 14.896 LAYER metal5 ;
    ANTENNAGATEAREA 0.13975 LAYER metal5 ; 
    ANTENNAMAXAREACAR 91.154 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 366.08 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.98705 LAYER via5 ;
  END OUT6[15]
  PIN OUT6[14] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.0819 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3472 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 1.8333 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.3528 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 6.5072 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 26.1856 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 1.4308 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 5.8016 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal5 ; 
    ANTENNAMAXAREACAR 40.5192 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 163.611 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.497873 LAYER via5 ;
  END OUT6[14]
  PIN OUT6[13] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.672 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.7076 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.2394 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9968 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 4.6844 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 19.1296 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 1.1172 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.5472 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal5 ; 
    ANTENNAMAXAREACAR 38.7525 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 156.638 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.638881 LAYER via5 ;
  END OUT6[13]
  PIN OUT6[12] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.9163 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.7044 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.64435 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.6166 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.5292 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.1952 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 12.0736 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 48.4512 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal5 ; 
    ANTENNAMAXAREACAR 143.431 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 577.55 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.736716 LAYER via5 ;
  END OUT6[12]
  PIN OUT6[11] 
    ANTENNAPARTIALMETALAREA 0.0812 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3016 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.0588 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2548 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 1.9026 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.63 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 9.3884 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 37.7104 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.13975 LAYER metal4 ; 
    ANTENNAMAXAREACAR 76.3324 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 306.118 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.317077 LAYER via4 ;
  END OUT6[11]
  PIN OUT6[10] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1078 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4508 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.4634 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.8732 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 9.0944 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 36.5344 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 0.8036 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2928 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal5 ; 
    ANTENNAMAXAREACAR 66.2727 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 268.792 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.877723 LAYER via5 ;
  END OUT6[10]
  PIN OUT6[9] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.0539 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2352 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 1.2474 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.0092 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 10.6624 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 42.728 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 117.198 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 470.501 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.466193 LAYER via4 ;
  END OUT6[9]
  PIN OUT6[8] 
    ANTENNAPARTIALMETALAREA 0.0413 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1534 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.2842 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1564 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.4375 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.7696 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 9.1924 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 36.848 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 122.074 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 489.312 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.466193 LAYER via4 ;
  END OUT6[8]
  PIN OUT6[7] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.8827 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5504 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.7091 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9344 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 4.018 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.1504 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 43.8508 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 175.997 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.227351 LAYER via4 ;
  END OUT6[7]
  PIN OUT6[6] 
    ANTENNAPARTIALMETALAREA 0.0147 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0546 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.1347 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.578 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.2415 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9856 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 3.8024 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.288 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 4.6648 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 18.816 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal5 ; 
    ANTENNAMAXAREACAR 85.2094 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 342.813 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.400038 LAYER via5 ;
  END OUT6[6]
  PIN OUT6[5] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.4879 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.9712 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.7455 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.0408 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 2.0188 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.232 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 1.47 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 5.9584 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal5 ; 
    ANTENNAMAXAREACAR 44.4485 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 179.328 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.497873 LAYER via5 ;
  END OUT6[5]
  PIN OUT6[4] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.5488 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.2148 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.9044 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.6372 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 1.0584 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.312 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 0.3332 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 1.4112 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal5 ; 
    ANTENNAMAXAREACAR 69.1371 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 278.179 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.400038 LAYER via5 ;
  END OUT6[4]
  PIN OUT6[3] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1176 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.49 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.1862 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7644 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 1.2936 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.2528 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 4.7824 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 19.2864 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal5 ; 
    ANTENNAMAXAREACAR 97.5631 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 394.549 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.497873 LAYER via5 ;
  END OUT6[3]
  PIN OUT6[2] 
    ANTENNAPARTIALMETALAREA 0.0147 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0546 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1078 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4508 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.3689 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.4952 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 1.7052 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.8992 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 0.49 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0384 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.13975 LAYER metal5 ; 
    ANTENNAMAXAREACAR 67.4306 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 271.626 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.598335 LAYER via5 ;
  END OUT6[2]
  PIN OUT6[1] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.2338 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9548 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 1.7878 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.21 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 7.0364 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 28.3024 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 3.43 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 13.7984 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.13975 LAYER metal5 ; 
    ANTENNAMAXAREACAR 34.1129 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 138.215 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.457327 LAYER via5 ;
  END OUT6[1]
  PIN OUT6[0] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.2569 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0472 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.308 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.2712 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 5.7428 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 23.0496 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 0.882 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 3.6064 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1395 LAYER metal5 ; 
    ANTENNAMAXAREACAR 24.156 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 97.9266 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.457642 LAYER via5 ;
  END OUT6[0]
  PIN OUT7[19] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.2107 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8624 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2758 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1228 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.11325 LAYER metal3 ; 
    ANTENNAMAXAREACAR 6.40124 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 25.2774 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT7[19]
  PIN OUT7[18] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.7343 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9568 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2758 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1228 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.03475 LAYER metal3 ; 
    ANTENNAMAXAREACAR 9.50791 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 39.0964 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT7[18]
  PIN OUT7[17] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.4564 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.8452 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.4354 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.7612 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.13975 LAYER metal3 ; 
    ANTENNAMAXAREACAR 6.7889 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 27.0787 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT7[17]
  PIN OUT7[16] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.8981 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.6316 LAYER metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.105 LAYER metal2 ; 
    ANTENNAMAXAREACAR 10.14 LAYER metal2 ;
    ANTENNAMAXSIDEAREACAR 40.5295 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.0933333 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2758 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1228 LAYER metal3 ;
    ANTENNAGATEAREA 0.13975 LAYER metal3 ; 
    ANTENNAMAXAREACAR 12.1135 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 48.5639 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT7[16]
  PIN OUT7[15] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.0245 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1176 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.7441 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.0156 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.13975 LAYER metal3 ; 
    ANTENNAMAXAREACAR 12.2507 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 49.0198 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.211132 LAYER via3 ;
  END OUT7[15]
  PIN OUT7[14] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.5908 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.3828 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.9772 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.9284 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 14.1085 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 56.3375 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.184179 LAYER via3 ;
  END OUT7[14]
  PIN OUT7[13] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.5152 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0804 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 1.505 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.0592 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 16.7977 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 67.3431 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT7[13]
  PIN OUT7[12] 
    ANTENNAPARTIALMETALAREA 0.0182 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0676 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.0588 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2548 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 1.218 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.8916 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 1.5484 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.272 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 20.0395 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 81.0013 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.325186 LAYER via4 ;
  END OUT7[12]
  PIN OUT7[11] 
    ANTENNAPARTIALMETALAREA 0.0147 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0546 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1666 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.686 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 1.3055 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.2808 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 18.5324 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 75.1485 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.423022 LAYER via3 ;
  END OUT7[11]
  PIN OUT7[10] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1568 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6468 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.7742 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.1164 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 2.156 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.7808 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 39.1798 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 159.729 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.705036 LAYER via4 ;
  END OUT7[10]
  PIN OUT7[9] 
    ANTENNAPARTIALMETALAREA 0.0182 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0676 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.1081 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.4716 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.4452 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.8004 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 10.2261 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 40.8079 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.184179 LAYER via3 ;
  END OUT7[9]
  PIN OUT7[8] 
    ANTENNAPARTIALMETALAREA 0.0413 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1534 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1176 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.49 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.2457 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0024 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 0.9212 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.7632 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 28.7216 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 116.596 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.466193 LAYER via4 ;
  END OUT7[8]
  PIN OUT7[7] 
    ANTENNAPARTIALMETALAREA 0.0049 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0182 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.0147 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0784 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.7105 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.8616 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 1.3916 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.6448 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 18.8997 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 76.6145 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.325186 LAYER via4 ;
  END OUT7[7]
  PIN OUT7[6] 
    ANTENNAPARTIALMETALAREA 0.0049 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0182 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.9527 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.85 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.4354 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.7612 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 11.9428 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 47.7508 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT7[6]
  PIN OUT7[5] 
    ANTENNAPARTIALMETALAREA 0.0812 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3016 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.2173 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.8888 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.3654 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.4812 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 10.4105 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 41.6216 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT7[5]
  PIN OUT7[4] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.3304 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3412 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.6559 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.6628 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 12.3477 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 49.5433 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT7[4]
  PIN OUT7[3] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.7427 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9904 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.5845 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.3772 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 8.43867 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 33.907 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT7[3]
  PIN OUT7[2] 
    ANTENNAPARTIALMETALAREA 0.0049 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0182 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.3675 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.4896 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.1365 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5656 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 1.7052 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.8992 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 22.86 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 92.283 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.466193 LAYER via4 ;
  END OUT7[2]
  PIN OUT7[1] 
    ANTENNAPARTIALMETALAREA 0.2107 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7826 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.0199 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.0992 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2758 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1228 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 8.54551 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 34.1617 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT7[1]
  PIN OUT7[0] 
    ANTENNAPARTIALMETALAREA 0.0147 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0546 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.2289 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9352 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.0441 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.196 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 0.8232 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.4496 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1395 LAYER metal4 ; 
    ANTENNAMAXAREACAR 16.7788 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 69.3039 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.423022 LAYER via4 ;
  END OUT7[0]
  PIN OUT8[19] 
    ANTENNAPARTIALMETALAREA 0.0182 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0676 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.3759 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5232 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.6748 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.7188 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.11325 LAYER metal3 ; 
    ANTENNAMAXAREACAR 10.9098 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 43.3115 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT8[19]
  PIN OUT8[18] 
    ANTENNAPARTIALMETALAREA 0.0413 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1534 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.2058 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8624 LAYER metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.03475 LAYER metal2 ; 
    ANTENNAMAXAREACAR 6.9295 LAYER metal2 ;
    ANTENNAMAXSIDEAREACAR 28.7827 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2758 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1228 LAYER metal3 ;
    ANTENNAGATEAREA 0.03475 LAYER metal3 ; 
    ANTENNAMAXAREACAR 14.8662 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 61.0935 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT8[18]
  PIN OUT8[17] 
    ANTENNAPARTIALMETALAREA 0.0945 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.351 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.2156 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.882 LAYER metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.03475 LAYER metal2 ; 
    ANTENNAMAXAREACAR 7.21151 LAYER metal2 ;
    ANTENNAMAXSIDEAREACAR 29.3468 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.3752 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.54 LAYER metal3 ;
    ANTENNAGATEAREA 0.13975 LAYER metal3 ; 
    ANTENNAMAXAREACAR 9.89631 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 40.3664 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT8[17]
  PIN OUT8[16] 
    ANTENNAPARTIALMETALAREA 0.0049 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0182 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.4165 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.6856 LAYER metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.105 LAYER metal2 ; 
    ANTENNAMAXAREACAR 5.55333 LAYER metal2 ;
    ANTENNAMAXSIDEAREACAR 21.9962 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.0933333 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.4088 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.6548 LAYER metal3 ;
    ANTENNAGATEAREA 0.13975 LAYER metal3 ; 
    ANTENNAMAXAREACAR 8.47856 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 33.8373 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT8[16]
  PIN OUT8[15] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1323 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5488 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.3255 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3412 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.13975 LAYER metal3 ; 
    ANTENNAMAXAREACAR 9.39561 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 37.5994 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.211132 LAYER via3 ;
  END OUT8[15]
  PIN OUT8[14] 
    ANTENNAPARTIALMETALAREA 0.0182 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0676 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 2.3912 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.604 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.7707 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.122 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 10.0792 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 40.4691 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT8[14]
  PIN OUT8[13] 
    ANTENNAPARTIALMETALAREA 0.01715 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0637 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.0784 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3332 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.0385 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1736 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 4.4884 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.1888 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 48.94 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 197.812 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.325186 LAYER via4 ;
  END OUT8[13]
  PIN OUT8[12] 
    ANTENNAPARTIALMETALAREA 0.0182 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0676 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.448 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.8116 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.3402 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.4 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 2.5676 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.4272 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 37.9376 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 153.685 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.423022 LAYER via4 ;
  END OUT8[12]
  PIN OUT8[11] 
    ANTENNAPARTIALMETALAREA 0.0413 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1534 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1274 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5292 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.8295 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3376 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 4.5668 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.3456 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.13975 LAYER metal4 ; 
    ANTENNAMAXAREACAR 40.4569 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 161.915 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.317077 LAYER via4 ;
  END OUT8[11]
  PIN OUT8[10] 
    ANTENNAPARTIALMETALAREA 0.0413 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1534 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.5663 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.2848 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.1414 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6048 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 3.2928 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.328 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 38.819 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 157.155 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.466193 LAYER via4 ;
  END OUT8[10]
  PIN OUT8[9] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1225 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5096 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.3864 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5652 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 4.5472 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.3456 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 0.7252 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9792 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal5 ; 
    ANTENNAMAXAREACAR 42.977 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 174.354 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.595709 LAYER via5 ;
  END OUT8[9]
  PIN OUT8[8] 
    ANTENNAPARTIALMETALAREA 0.3934 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 1.4612 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.9583 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.8528 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.014 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0756 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 5.8408 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 23.52 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 61.7065 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 248.36 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.325186 LAYER via4 ;
  END OUT8[8]
  PIN OUT8[7] 
    ANTENNAPARTIALMETALAREA 0.1078 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4004 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.1585 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.6536 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 3.9088 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.694 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 2.4108 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.8 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 9.2708 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 37.1616 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal5 ; 
    ANTENNAMAXAREACAR 105.63 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 424.302 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.497873 LAYER via5 ;
  END OUT8[7]
  PIN OUT8[6] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1883 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7728 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.0546 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.238 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 5.0568 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 20.384 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 57.2045 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 230.352 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.325186 LAYER via4 ;
  END OUT8[6]
  PIN OUT8[5] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.3682 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.4924 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.0357 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1624 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 5.684 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 22.8928 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 65.005 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 261.478 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.227351 LAYER via4 ;
  END OUT8[5]
  PIN OUT8[4] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1127 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4704 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.392 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5876 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 6.2916 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 25.3232 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 71.481 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 287.631 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.325186 LAYER via4 ;
  END OUT8[4]
  PIN OUT8[3] 
    ANTENNAPARTIALMETALAREA 0.0049 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0182 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 5.4446 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 21.8176 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 1.4959 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.0228 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 18.9531 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 75.9646 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT8[3]
  PIN OUT8[2] 
    ANTENNAPARTIALMETALAREA 5.215 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 19.37 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 3.885 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 15.5596 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 5.17895 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 20.755 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.13975 LAYER metal3 ; 
    ANTENNAMAXAREACAR 40.6049 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 161.946 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT8[2]
  PIN OUT8[1] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.2873 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.1688 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 1.2292 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.9952 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.13975 LAYER metal3 ; 
    ANTENNAMAXAREACAR 14.0331 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 57.1942 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.423022 LAYER via3 ;
  END OUT8[1]
  PIN OUT8[0] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.3412 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.404 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.0469 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2072 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 3.4496 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.9552 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1395 LAYER metal4 ; 
    ANTENNAMAXAREACAR 37.4113 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 151.691 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.599154 LAYER via4 ;
  END OUT8[0]
  PIN OUT9[19] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.5481 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.212 LAYER metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.11325 LAYER metal2 ; 
    ANTENNAMAXAREACAR 6.79929 LAYER metal2 ;
    ANTENNAMAXSIDEAREACAR 26.6199 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.184274 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2758 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1228 LAYER metal3 ;
    ANTENNAGATEAREA 0.11325 LAYER metal3 ; 
    ANTENNAMAXAREACAR 9.23461 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 36.5343 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.184274 LAYER via3 ;
  END OUT9[19]
  PIN OUT9[18] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1225 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5096 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.4753 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.9208 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.03475 LAYER metal3 ; 
    ANTENNAMAXAREACAR 17.505 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 71.0849 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT9[18]
  PIN OUT9[17] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.3941 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.596 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.4221 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.708 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.13975 LAYER metal3 ; 
    ANTENNAMAXAREACAR 5.54039 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 22.3916 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT9[17]
  PIN OUT9[16] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.0735 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3136 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.0252 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1204 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 0.0392 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2352 LAYER metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER via4 ;
    ANTENNADIFFAREA 0.109725 LAYER metal5 ; 
    ANTENNAPARTIALMETALAREA 0.2548 LAYER metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0976 LAYER metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.13975 LAYER metal5 ; 
    ANTENNAMAXAREACAR 13.3037 LAYER metal5 ;
    ANTENNAMAXSIDEAREACAR 54.9777 LAYER metal5 ;
    ANTENNAMAXCUTCAR 0.457327 LAYER via5 ;
  END OUT9[16]
  PIN OUT9[15] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1715 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7056 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.9072 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.668 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.13975 LAYER metal3 ; 
    ANTENNAMAXAREACAR 15.5966 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 63.1677 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.423022 LAYER via3 ;
  END OUT9[15]
  PIN OUT9[14] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.0343 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1568 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.9632 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.892 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 14.0191 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 56.1524 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.184179 LAYER via3 ;
  END OUT9[14]
  PIN OUT9[13] 
    ANTENNAPARTIALMETALAREA 0.2506 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9308 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.2842 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1564 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.6377 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.59 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 9.7944 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 39.2538 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.184179 LAYER via3 ;
  END OUT9[13]
  PIN OUT9[12] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1176 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.49 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.8302 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3992 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 15.3922 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 62.7604 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.423022 LAYER via3 ;
  END OUT9[12]
  PIN OUT9[11] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1274 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5292 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.95935 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.8766 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.13975 LAYER metal3 ; 
    ANTENNAMAXAREACAR 13.5676 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 53.7967 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT9[11]
  PIN OUT9[10] 
    ANTENNAPARTIALMETALAREA 0.0812 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3016 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.1179 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.5108 LAYER metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.03475 LAYER metal2 ; 
    ANTENNAMAXAREACAR 33.177 LAYER metal2 ;
    ANTENNAMAXSIDEAREACAR 133.773 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.3654 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5008 LAYER metal3 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 36.3964 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 146.996 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT9[10]
  PIN OUT9[9] 
    ANTENNAPARTIALMETALAREA 0.0049 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0182 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1029 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4312 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.2443 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9968 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 1.9404 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 7.84 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 28.349 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 114.412 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.325186 LAYER via4 ;
  END OUT9[9]
  PIN OUT9[8] 
    ANTENNAPARTIALMETALAREA 0.0049 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0182 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.3647 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.4784 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.4718 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.9264 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 13.5524 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 54.3619 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT9[8]
  PIN OUT9[7] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.1127 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4704 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.0994 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4172 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 2.9596 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.9952 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 37.6786 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 153.725 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.564029 LAYER via4 ;
  END OUT9[7]
  PIN OUT9[6] 
    ANTENNAPARTIALMETALAREA 0.0945 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.351 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.196 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8036 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.2513 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0248 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 3.1948 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.0144 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 43.7998 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 178.336 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.564029 LAYER via4 ;
  END OUT9[6]
  PIN OUT9[5] 
    ANTENNAPARTIALMETALAREA 0.0049 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0182 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.0931 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.392 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.2359 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9632 LAYER metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via3 ;
    ANTENNADIFFAREA 0.109725 LAYER metal4 ; 
    ANTENNAPARTIALMETALAREA 2.6264 LAYER metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.584 LAYER metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal4 ; 
    ANTENNAMAXAREACAR 34.5022 LAYER metal4 ;
    ANTENNAMAXSIDEAREACAR 138.852 LAYER metal4 ;
    ANTENNAMAXCUTCAR 0.325186 LAYER via4 ;
  END OUT9[5]
  PIN OUT9[4] 
    ANTENNAPARTIALMETALAREA 0.0049 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0182 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.224 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9156 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.4683 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.932 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 25.4771 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 102.233 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT9[4]
  PIN OUT9[3] 
    ANTENNAPARTIALMETALAREA 0.01575 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0585 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.6363 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5648 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.6048 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.4584 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1135 LAYER metal3 ; 
    ANTENNAMAXAREACAR 22.2797 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 89.2713 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT9[3]
  PIN OUT9[2] 
    ANTENNAPARTIALMETALAREA 0.1043 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3874 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 1.05175 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.2266 LAYER metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.105 LAYER metal2 ; 
    ANTENNAMAXAREACAR 12.6662 LAYER metal2 ;
    ANTENNAMAXSIDEAREACAR 49.9105 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.0933333 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2954 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.2012 LAYER metal3 ;
    ANTENNAGATEAREA 0.13975 LAYER metal3 ; 
    ANTENNAMAXAREACAR 14.78 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 58.5058 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.282014 LAYER via3 ;
  END OUT9[2]
  PIN OUT9[1] 
    ANTENNAPARTIALMETALAREA 0.028 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.104 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.5684 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.2932 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.3752 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5204 LAYER metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.13975 LAYER metal3 ; 
    ANTENNAMAXAREACAR 7.16258 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 27.9899 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.17607 LAYER via3 ;
  END OUT9[1]
  PIN OUT9[0] 
    ANTENNAPARTIALMETALAREA 0.0812 LAYER metal1 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3016 LAYER metal1 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via1 ;
    ANTENNAPARTIALMETALAREA 0.8036 LAYER metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.234 LAYER metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1395 LAYER metal2 ; 
    ANTENNAMAXAREACAR 7.34602 LAYER metal2 ;
    ANTENNAMAXSIDEAREACAR 29.3756 LAYER metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.176133 LAYER via2 ;
    ANTENNADIFFAREA 0.109725 LAYER metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2093 LAYER metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8568 LAYER metal3 ;
    ANTENNAGATEAREA 0.1395 LAYER metal3 ; 
    ANTENNAMAXAREACAR 8.84637 LAYER metal3 ;
    ANTENNAMAXSIDEAREACAR 35.5176 LAYER metal3 ;
    ANTENNAMAXCUTCAR 0.176133 LAYER via3 ;
  END OUT9[0]
END systolic_array

END LIBRARY
